# Keil uVision project EepRomTest.uvprojx, settings and files
target Templet (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: EepRomTest +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_CL,USE_STDPERIPH_DRIVER
  c include: ..\User;..\StCore;..\Stm32F10x_FwLib\inc;.\system;.\drivers;.\drivers\led;.\drivers\delay;.\drivers\usart;.\drivers\timer;.\drivers\eeprom;.\drivers\iic
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group StCore
    ../StCore/: core_cm3.c startup_stm32f10x_cl.s
  group Stm32F10x_Fwlib
    ../Stm32F10x_FwLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group System
    ./system/: stm32f10x_it.c system_stm32f10x.c
  group User
    ./: main.c
  group Drivers
    ./drivers/led/: led.c
    ./drivers/delay/: delay.c
    ./drivers/usart/: Uart.c UartCom2.c
    ./drivers/timer/: TotalTimer.c Timer3.c
    ./drivers/iic/: iic.c
    ./drivers/eeprom/: eeprom.c
